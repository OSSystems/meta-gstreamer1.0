require gstreamer1.0-python.inc

SRC_URI = "http://gstreamer.freedesktop.org/src/${PNREAL}/${PNREAL}-${PV}.tar.xz"
SRC_URI[md5sum] = "2ae86f1bb2fd8399a942fd94bb17d264"
SRC_URI[sha256sum] = "1bc6704955e343f78d2d935487f26d2db4c131c9a6dad38eb331c7e3639147d3"

LIC_FILES_CHKSUM = "file://COPYING;md5=c34deae4e395ca07e725ab0076a5f740"
