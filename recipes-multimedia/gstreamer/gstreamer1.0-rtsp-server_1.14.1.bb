require gstreamer1.0-rtsp-server.inc

SRC_URI[md5sum] = "baa721c289880c2cc0e9c5cbebca5201"
SRC_URI[sha256sum] = "38634f3b25c2bf2967b1ff914b54ff384f8612f5aefc18accd72c78bf3b02d7c"

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"
