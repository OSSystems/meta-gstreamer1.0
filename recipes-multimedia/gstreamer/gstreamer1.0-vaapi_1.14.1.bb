require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "38c5b2390797b7a0a269a5ab6c8cbe8f"
SRC_URI[sha256sum] = "585c3ddb0c39220de0a33e5d0ed6196a108b8407ec3538d7c64617713b4434e8"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
