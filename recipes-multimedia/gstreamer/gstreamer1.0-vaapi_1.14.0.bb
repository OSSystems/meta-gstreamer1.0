require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "248c3aafab59814e71eb4a6c334cb261"
SRC_URI[sha256sum] = "e4e31f085ef289bf1049398f641345979d20a1b11a80285744bba98504991df2"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
