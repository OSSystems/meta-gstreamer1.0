require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "7548a48eece6c76298561f2ec890a240"
SRC_URI[sha256sum] = "4a1a5a174b3d3a76ce6c123203e7ee535a347d77f9d4f4ffaf69bfbbfeb03ddb"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
