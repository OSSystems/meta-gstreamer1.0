require gstreamer1.0-rtsp-server.inc

SRC_URI[md5sum] = "70815a2ca055e1d8505965b17ac79aeb"
SRC_URI[sha256sum] = "85ae6bbe173b365ddf4859967144f1999b436531ecbe09935914bfa9f6b37652"

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"
