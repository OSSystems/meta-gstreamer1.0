include gstreamer1.0-rtsp-server.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"

SRC_URI[md5sum] = "c8162f67c184663c1e1aa3ce872ef1e3"
SRC_URI[sha256sum] = "1e1526d700ba36df5b30c887ccc37179903255022e57f716afb3ef172fe0746f"
